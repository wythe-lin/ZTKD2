# Keil uVision project D2SPI_2K.uvproj, settings and files
target D2SPI_2K (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: D2SPI_2K +hex
  AfterMake: .\HEX2BIN.EXE  /o0x0 OBJLST/D2SPI_2K.hex D2SPI_2K.bin
  c flags: Optimize=8 SizeSpeed=1
  c define: SPI_INTERFACE
  group SOURCE
    ./SOURCE/: main.c STARTUP.A51 uart.c spi.c d2.c
