# Keil uVision project ZT3150LIB.uvproj, settings and files
target ZT3150 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: ZT3150 +hex (library)
  AfterMake: xcopy OBJLST\ZT3150.lib ZT3150 /y
  c flags: Optimize=8 SizeSpeed=1
  c define: ZT3150
  c include: .\ZT3150;.\SOLUTIONS;.\SOURCE
  group SOLUTIONS
    ./SOLUTIONS/: zt3150.c zt3150table1.c zt3150table2.c
  group SOURCE
    ./SOURCE/: main.c STARTUP.A51 i2c.c sensor0.c sensor1.c d2.c
