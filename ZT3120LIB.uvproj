# Keil uVision project ZT3120LIB.uvproj, settings and files
target ZT3120 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: ZT3120 +hex (library)
  AfterMake: xcopy OBJLST\ZT3120.lib ZT3120 /y
  c flags: Optimize=8 SizeSpeed=1
  c define: ZT3120
  c include: .\ZT3120;.\SOURCE;.\SOLUTIONS
  group SOLUTIONS
    ./SOLUTIONS/: zt3120.c
  group SOURCE
    ./SOURCE/: main.c STARTUP.A51 i2c.c sensor0.c sensor1.c d2.c
