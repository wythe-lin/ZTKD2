# Keil uVision project ZT3150.uvproj, settings and files
target ZT3150 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: ZT3150 +hex
  AfterMake: ..\HEX2BIN.EXE  /o0x0 OBJLST/ZT3150.hex ZT3150.bin
  c flags: Optimize=8 SizeSpeed=1
  c define: ZT3150
  group RELEASE
    ./: ZT3150.LIB zt3150_sensor.c
