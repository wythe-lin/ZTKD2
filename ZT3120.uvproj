# Keil uVision project ZT3120.uvproj, settings and files
target ZT3120 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: ZT3120 +hex
  AfterMake: .\HEX2BIN.EXE  /o0x0 OBJLST/ZT3120.hex ZT3120.bin
  c flags: Optimize=8 SizeSpeed=1
  c define: ZT3120
  c include: .\SOURCE;.\SOLUTIONS
  group SOLUTIONS
    ./SOLUTIONS/: zt3120.c
  group SOURCE
    ./SOURCE/: main.c STARTUP.A51 uart.c i2c.c sensor0.c sensor1.c d2.c
  group RELEASE
    ./ZT3120/: zt3120_sensor.c
